# Keil uVision project PioneerKit_P5LP_USB_Audio_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5667LTI-LP009 Cypress
  cpu: "IRAM(0x1FFFC000-0x20003FFF)IROM(0x0-0x1FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: PioneerKit_P5LP_USB_Audio_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PSOC_I2S_SCLK_aliases.h PSOC_I2S_SCLK.c PSOC_I2S_SCLK.h I2S.c I2S.h I2S_PM.c AudioClkGen.c AudioClkGen.h AudioClkGen_Ref.c AudioClkGen_Ref.h PSOC_CODEC_RST_aliases.h PSOC_CODEC_RST.c PSOC_CODEC_RST.h TxDMA_dma.c TxDMA_dma.h isr_TxDMADone.c isr_TxDMADone.h PSOC_I2S_SDTO_aliases.h PSOC_I2S_SDTO.c PSOC_I2S_SDTO.h isr_InDMADone.c isr_InDMADone.h USBInDMA_dma.c USBInDMA_dma.h PSOC_I2S_MCLK_aliases.h PSOC_I2S_MCLK.c PSOC_I2S_MCLK.h USBOutDMA_dma.c USBOutDMA_dma.h PSOC_SW_aliases.h PSOC_SW.c PSOC_SW.h SystemTickTimer.c SystemTickTimer.h isr_Tick.c isr_Tick.h I2C_Master.c I2C_Master.h I2C_Master_BOOT.c I2C_Master_INT.c I2C_Master_PM.c I2C_Master_SLAVE.c I2C_Master_MASTER.c I2C_Master_PVT.h PSOC_I2S_LRCLK_aliases.h PSOC_I2S_LRCLK.c PSOC_I2S_LRCLK.h I2S_Tx_DMA_dma.c I2S_Tx_DMA_dma.h ByteSwap_Tx.c ByteSwap_Tx.h clock_CIC.c clock_CIC.h CICOut_L_dma.c CICOut_L_dma.h CICOut_R_dma.c CICOut_R_dma.h Droop_Filter.c Droop_Filter.h Droop_Filter_PM.c Droop_Filter_RAM_Data.c RxDMA_dma.c RxDMA_dma.h isr_RxDMADone.c isr_RxDMADone.h AudioClkGen_Clock_SCK.c AudioClkGen_Clock_SCK.h AudioClkGen_Clock_I2S.c AudioClkGen_Clock_I2S.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h SDA_aliases.h SDA.c SDA.h SCL_aliases.h SCL.c SCL.h PSOC_STATUS_LED_aliases.h PSOC_STATUS_LED.c PSOC_STATUS_LED.h USBFS.c USBFS.h USBFS_audio.c USBFS_audio.h USBFS_boot.c USBFS_cdc.c USBFS_cdc.h USBFS_cls.c USBFS_descr.c USBFS_drv.c USBFS_episr.c USBFS_hid.c USBFS_hid.h USBFS_pm.c USBFS_std.c USBFS_vnd.c USBFS_cdc.inf USBFS_midi.c USBFS_midi.h USBFS_Dm_aliases.h USBFS_Dm.c USBFS_Dm.h USBFS_Dp_aliases.h USBFS_Dp.c USBFS_Dp.h USBFS_ep1_dma.c USBFS_ep1_dma.h USBFS_ep2_dma.c USBFS_ep2_dma.h USBFS_ep4_dma.c USBFS_ep4_dma.h USBFS_ep6_dma.c USBFS_ep6_dma.h isr_CICOverflow.c isr_CICOverflow.h PDM_CIC.h PDM_CIC.c PDM_CIC_DMA_CombD0Update_R_dma.c PDM_CIC_DMA_CombD0Update_R_dma.h PDM_CIC_DMA_CombD0Update_L_dma.c PDM_CIC_DMA_CombD0Update_L_dma.h PDM_CIC_Int_Ctrl_Reg.c PDM_CIC_Int_Ctrl_Reg.h PDM_CIC_Status_Reg.c PDM_CIC_Status_Reg.h PDM_CIC_DMA_IntOut_L_dma.c PDM_CIC_DMA_IntOut_L_dma.h PDM_CIC_DMA_IntOut_R_dma.c PDM_CIC_DMA_IntOut_R_dma.h PSOC_PDM_DataIn_aliases.h PSOC_PDM_DataIn.c PSOC_PDM_DataIn.h PSOC_PDM_ClkOut_aliases.h PSOC_PDM_ClkOut.c PSOC_PDM_ClkOut.h PSOC_PDM_LR_SEL_aliases.h PSOC_PDM_LR_SEL.c PSOC_PDM_LR_SEL.h Droop_Filter_PVT.c Droop_Filter_PVT.h Droop_Filter_Coefficients.c
target Release (ARM-GNU)
  device: CY8C5667LTI-LP009 Cypress
  cpu: as above
  output: PioneerKit_P5LP_USB_Audio_PSoC5lib (library)
